options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: baseband_fft
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,6,1,1
    label: baseband_fft
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '1'
  states: {}
- name: bb_channel
  id: variable
  parameters:
    value: '[(cf+fine)-channels[0],(cf+fine)-channels[1],(cf+fine)-channels[2],(cf+fine)-channels[3]]'
  states: {}
- name: cf
  id: variable
  parameters:
    value: 147e6
  states: {}
- name: chan_1
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,5,1,1
    type: real
    value: 147.3e6
  states: {}
- name: chan_2
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,5,1,1
    type: real
    value: 147.3e6
  states: {}
- name: chan_3
  id: variable_qtgui_label
  parameters:
    gui_hint: 3,5,1,1
    type: real
    value: 147.3e6
  states: {}
- name: chan_4
  id: variable_qtgui_label
  parameters:
    gui_hint: 4,5,1,1
    type: real
    value: 147.3e6
  states: {}
- name: channels
  id: variable
  parameters:
    value: '[chan_1 ,chan_2,chan_3,chan_4]'
  states: {}
- name: filter_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,2
    start: '3000'
    step: '1000'
    stop: '6000'
    value: '5000'
  states: {}
- name: fine
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,2
    start: '-500000'
    step: '1000'
    stop: '500000'
    value: '300000'
  states: {}
- name: fm_deviation
  id: variable
  parameters:
    value: '4500'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,6,1,1
    start: '0'
    step: '1000'
    stop: '1'
    value: '0'
  states: {}
- name: int_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: rate_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,4,1,1
    start: '512'
    step: '2'
    stop: '2400'
    value: '1200'
  states: {}
- name: rate_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,4,1,1
    start: '512'
    step: '2'
    stop: '2400'
    value: '1200'
  states: {}
- name: rate_3
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,4,1,1
    start: '512'
    step: '2'
    stop: '2400'
    value: '1200'
  states: {}
- name: rate_4
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,4,1,1
    start: '512'
    step: '2'
    stop: '2400'
    value: '1200'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '[(1+fm_deviation*2/sym_rates[0])*2,2*(1+fm_deviation*2/sym_rates[1]),2*(1+fm_deviation*2/sym_rates[2]),2*(1+fm_deviation*2/sym_rates[3])]'
  states: {}
- name: sr
  id: variable
  parameters:
    value: ' 2000000'
  states: {}
- name: sym_rates
  id: variable
  parameters:
    value: '[rate_1,rate_2,rate_3,rate_4]'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass(10, sr, int_rate ,int_rate*0.5, window.WIN_HAMMING)
  states: {}
- name: taps_bb
  id: variable
  parameters:
    value: firdes.low_pass(10, int_rate, filter_offset ,2500, window.WIN_HAMMING)
  states: {}
- name: xlate_center
  id: variable
  parameters:
    value: fine
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: float(sym_rates[3] * sps[3]) / float(fm_deviation * 4)
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: float(sym_rates[2] * sps[2]) / float(fm_deviation * 4)
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: float(sym_rates[1] * sps[1]) / float(fm_deviation * 4)
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: float(sym_rates[0] * sps[0]) / float(fm_deviation * 4)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/out1.bits
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /tmp/out2.bits
    type: byte
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: /tmp/out3.bits
    type: byte
  states: {}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: /tmp/out4.bits
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: baseband_fft
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_1_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: 0.03 * 0.03 * 0.3
    mu: '0.4'
    omega: sps[0]
    omega_relative_limit: '1e-4'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: 0.03 * 0.03 * 0.3
    mu: '0.4'
    omega: sps[1]
    omega_relative_limit: '1e-4'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_1
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: 0.03 * 0.03 * 0.3
    mu: '0.4'
    omega: sps[2]
    omega_relative_limit: '1e-4'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_1_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: 0.03 * 0.03 * 0.3
    mu: '0.4'
    omega: sps[3]
    omega_relative_limit: '1e-4'
    type: float
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: bb_channel[0]
    decim: int((int_rate)/(sps[0]*sym_rates[0]))
    samp_rate: int_rate
    taps: taps_bb
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: bb_channel[1]
    decim: int((int_rate)/(sps[1]*sym_rates[1]))
    samp_rate: int_rate
    taps: taps_bb
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: bb_channel[3]
    decim: int((int_rate)/(sps[3]*sym_rates[3]))
    samp_rate: int_rate
    taps: taps_bb
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0_1
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: bb_channel[2]
    decim: int((int_rate)/(sps[2]*sym_rates[2]))
    samp_rate: int_rate
    taps: taps_bb
  states: {}
- name: freq_xlating_fft_filter_ccc_1
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-xlate_center'
    decim: sr//(int_rate)
    samp_rate: sr
    taps: taps
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: sym_rates[0] * 2
    decim: '1'
    gain: '1'
    samp_rate: sym_rates[0] * sps[0]
    type: fir_filter_fff
    width: sym_rates[0] / 2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: sym_rates[1] * 2
    decim: '1'
    gain: '1'
    samp_rate: sym_rates[1] * sps[1]
    type: fir_filter_fff
    width: sym_rates[1] / 2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: sym_rates[2] * 2
    decim: '1'
    gain: '1'
    samp_rate: sym_rates[2] * sps[2]
    type: fir_filter_fff
    width: sym_rates[2] / 2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: sym_rates[3] * 2
    decim: '1'
    gain: '1'
    samp_rate: sym_rates[3] * sps[3]
    type: fir_filter_fff
    width: sym_rates[3] / 2
    win: window.WIN_HAMMING
  states: {}
- name: notebook_0
  id: qtgui_tab_widget
  parameters:
    label0: Tab 0
    label1: Tab 1
    label2: Tab 2
    label3: Tab 3
    num_tabs: '4'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: int_rate/((int_rate)/(sps[baseband_fft]*sym_rates[baseband_fft]))
    fc: '0'
    fftsize: '512'
    gui_hint: notebook_0@2
    name: '"Channel Waterfall"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: int_rate
    fc: cf+fine
    fftsize: '512'
    gui_hint: notebook_0@1
    name: '"Baseband Waterfall"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sr
    fc: cf
    fftsize: '512'
    gui_hint: notebook_0@0
    name: '"RF Waterfall"'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: cf
    gain: gain
    samp_rate: sr
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0_1_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', low_pass_filter_0_1, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', low_pass_filter_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0, '0', low_pass_filter_0, '0']
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_null_sink_0_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_file_sink_1, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_null_sink_1_1, '0']
- [digital_binary_slicer_fb_0_1, '0', blocks_file_sink_2, '0']
- [digital_binary_slicer_fb_0_1, '0', blocks_null_sink_1, '0']
- [digital_binary_slicer_fb_0_1_0, '0', blocks_file_sink_3, '0']
- [digital_binary_slicer_fb_0_1_0, '0', blocks_null_sink_1_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_clock_recovery_mm_xx_0_1, '0', digital_binary_slicer_fb_0_1, '0']
- [digital_clock_recovery_mm_xx_0_1_0, '0', digital_binary_slicer_fb_0_1_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', analog_quadrature_demod_cf_0_0_0_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', blocks_selector_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', analog_quadrature_demod_cf_0_0_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', blocks_selector_0, '1']
- [freq_xlating_fft_filter_ccc_0_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fft_filter_ccc_0_0_0, '0', blocks_selector_0, '3']
- [freq_xlating_fft_filter_ccc_0_0_1, '0', analog_quadrature_demod_cf_0_0, '0']
- [freq_xlating_fft_filter_ccc_0_0_1, '0', blocks_selector_0, '2']
- [freq_xlating_fft_filter_ccc_1, '0', freq_xlating_fft_filter_ccc_0, '0']
- [freq_xlating_fft_filter_ccc_1, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [freq_xlating_fft_filter_ccc_1, '0', freq_xlating_fft_filter_ccc_0_0_0, '0']
- [freq_xlating_fft_filter_ccc_1, '0', freq_xlating_fft_filter_ccc_0_0_1, '0']
- [freq_xlating_fft_filter_ccc_1, '0', qtgui_waterfall_sink_x_1, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [low_pass_filter_0_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [low_pass_filter_0_1, '0', digital_clock_recovery_mm_xx_0_1, '0']
- [low_pass_filter_0_1_0, '0', digital_clock_recovery_mm_xx_0_1_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_1, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_2, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-55-g8526e6f8
